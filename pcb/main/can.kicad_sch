File: pcb/main/can.kicad_sch (KiCad schematic)
At the start: 3 parts, among them J10 Conn, J8 Conn, J9 Conn

Commit message: feat: finish main board v2
Other:
- moved on the sheet: J8, J9
